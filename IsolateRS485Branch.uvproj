# Keil uVision project IsolateRS485Branch.uvproj, settings and files
target Target (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0x7FFF) CLOCK(35000000) MODP2
  output: 电源隔离型RS485分支器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group system
    ./: STARTUP.A51 main.c system_init.c variable.c
  group driver
    ./driver/timer/: timer_drv.c
    ./driver/uart/: uart_drv.c
  group task
    ./task/uart/: uart_task.c
